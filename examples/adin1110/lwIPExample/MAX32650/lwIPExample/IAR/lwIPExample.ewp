# IAR project lwIPExample.ewp, settings and files
configuration Debug (OA SPI) (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; ADIN1110; SPI_OA_EN; SPI_PROT_EN; TARGET=32690; TARGET_REV=0x4131; BOARD_FTHR; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.PreInclude: errno.h
  ICCARM.CCIncludePath2: ..\..\..\Inc; ..\..\..\..\..\..\inc; ..\..\..\..\..\..\common; ..\..\..\..\..\..\common\hal; ..\..\..\src\cmdsrv; ..\..\..\src\contrib\ports\adin1110; ..\..\..\src\contrib\ports; ..\..\..\..\..\bsp\MAX32650; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..\..\..\..\..\..\external\lwip-2.1.2\src\include; ..\..\..\..\..\..\external\lwip-2.1.2\src\include\lwip; ..\..\..\..\..\..\external\lwip-2.1.2\src\include/ipv4; ..\..\..\..\..\..\external\lwip-2.1.2\src\include/netif
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: lwIPExample.hex
  ILINK.IlinkOutputFile: lwIPExample.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32690#1.2.1}$\.iar\config\linker\MAX32690_IAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (Generic SPI) (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; ADIN1110; SPI_CRC_EN; TARGET=MAX32690; TARGET_REV=0x4131; BOARD_FTHR; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: eval-adin1110ebz.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32690#1.2.1}$/.iar/config/linker/MAX32690_IAR.icf
  group adin1110 Driver
    ../../../../../../src/: adi_mac.c adi_phy.c adi_spi_generic.c adi_spi_oa.c adin1110.c
  group hal
    ../../../../../../common/hal/fcs/: fcs.c
  group hal/MAX32650
    ../../../../../bsp/MAX32650/: board.c max32650_hal.c
  group src
    ../../../src/: lwIP_adin1110_app.c main.c
  group src/lwIP
    ../../../src/contrib/ports/adin1110/: lwipopts.h
  group src/lwIP/apps
    ../../../../../../external/lwip-2.1.2/src/apps/http/: fs.c httpd.c
  group src/lwIP/core
    ../../../../../../external/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group src/lwIP/core/ipv4
    ../../../../../../external/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group src/lwIP/netif
    ../../../../../../external/lwip-2.1.2/src/netif/: ethernet.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Maxim MAX32690 BSP _BSP.EvKit V1_1.2.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.2.1}$/Libraries/Boards/MAX32690/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.2.1}$/Libraries/Boards/MAX32690/Source/: led.c pb.c stdio.c
  group CMSIS-Pack/Maxim Maxim API _Device.DMA_1.2.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.2.1}$/Libraries/PeriphDrivers/Source/DMA/: dma_me18.c dma_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.2.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.2.1}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me18.c gpio_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.ICC_1.2.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.2.1}$/Libraries/PeriphDrivers/Source/ICC/: icc_me18.c icc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.RTC_1.2.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.2.1}$/Libraries/PeriphDrivers/Source/RTC/: rtc_me18.c rtc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPI_1.2.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.2.1}$/Libraries/PeriphDrivers/Source/SPI/: spi_me18.c spi_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.2.1
    RTE/Device/MAX32690_Cortex-M4/: cmain.s heap.c low_level_init.c max32690.h startup_max32690.s system_max32690.c
  group CMSIS-Pack/Maxim Maxim API _Device.SYS_1.2.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.2.1}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me18.c sys_me18.c
  group CMSIS-Pack/Maxim Maxim API _Device.Timers_1.2.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.2.1}$/Libraries/PeriphDrivers/Source/TMR/: tmr_common.c tmr_me18.c tmr_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.2.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.2.1}$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me18.c uart_revb.c
